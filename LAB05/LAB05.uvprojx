# Keil uVision project LAB05.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: LPC4088FET208 NXP
  pack: Keil.LPC4000_DFP.2.2.1
  cpu: IRAM(0x10000000,0x10000) IRAM2(0x20000000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LAB05
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  asm include: ..\LPC4088
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Source Group 1
    ../LPC4088/: startup_LPC407x_8x_177x_8x.s board.s
    ./: LucasKelley_Lab05_Part_A.s LucasKelley_Lab05_Part_B.s
